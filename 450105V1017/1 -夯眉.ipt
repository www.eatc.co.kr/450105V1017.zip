# Autodesk Inventor part: 답안도면
## iProperties
Created: 2015-01
Part Number: 답안도면
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Author: Administrator
